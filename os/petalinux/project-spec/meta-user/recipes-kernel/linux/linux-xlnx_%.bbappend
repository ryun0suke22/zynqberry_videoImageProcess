SRC_URI += "file://user_2017-05-26-17-58-00.cfg \
            file://user_2017-05-26-18-20-00.cfg \
            file://user_2017-05-29-10-46-00.cfg \
            file://user_2017-05-29-11-11-00.cfg \
            file://user_2017-05-29-12-22-00.cfg \
            file://user_2017-05-29-17-55-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

